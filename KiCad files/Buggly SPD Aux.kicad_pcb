# Repository Hocus-Pocus/Buggly-SPD-Aux

File README.md:

# Buggly-SPD-Aux
Auxilliary board for Buggly SPD.
WORK IN PROGRESS

## KiCad design KiCad files/Buggly SPD Aux.kicad_pcb

Parts:
D1, D6, D7, D8, D9, D12, D13, D14, D17: LED; LED_D5.0mm
D2, D3, D4, D5, D15, D16: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
F1: 20A; 01530008Z_Fuse_Holder
F2: RXEF135-1; Fuse_Bourns_MF-RHT750
F3, F4, F5, F6, F7: 10A; 01530008Z_Fuse_Holder
J1: DB25_Female; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_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
J7: Screw_Terminal_01x02; Phoenix_1714955
J8: Screw_Terminal_01x08; Phoenix_1729076_Rt
J9: Screw_Terminal_01x07; Phoenix_1729063_Rt
J10: Screw_Terminal_01x08; Phoenix_1729076
K1, K2: Panasonic_CM1-R-12V; VCF4-1000
Q1, Q2, Q3, Q4: AUIRF3205; TO-220-3_Vertical_Wide
Q5, Q6: ISL9V3040P3; TO-220-3_Vertical_Wide
R1, R2, R3, R4, R5, R6, R7: 2.4k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9: 2.4K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1: R_Network04_US; R_Array_SIP5

Connections:
12V-Raw: F2.1, J1.5, R8.1
Bat+: F1.2, J7.2
Bat+s: D15.1 (K), J8.1, K1.86
CKP+: J1.14, J9.5
CKP-: J1.1, J9.6
CLT-Sensor: J1.24, J10.5
D5-control: J1.6, Q4.1 (G), RN1.5 (R4)
D5-out: D5.1 (A), J10.1, Q4.2 (D), R5.1
D6-control: J1.17, Q3.1 (G), RN1.4 (R3)
D6-out: D4.1 (A), J9.3, Q3.2 (D), R4.1
D8-control: J1.16, Q1.1 (G), RN1.2 (R1)
D8-out: D2.1 (A), J9.1, Q1.2 (D), R2.1
D9-control: J1.4, Q2.1 (G), RN1.3 (R2)
D9-out: D3.1 (A), J9.2, Q2.2 (D), R3.1
D38-control: J1.3, Q6.1 (G)
D38-out: J8.8, Q6.2 (C), R7.1
D40-control: J1.15, Q5.1 (G)
D40-out: J8.7, Q5.2 (C), R6.1
D45-control: D16.2 (A), J1.18, K2.85
F3-out: D7.1 (A), D8.1 (A), F3.2, J8.6
F4-out: D12.1 (A), D13.1 (A), F4.2, J8.5
F5-out: D4.2 (K), D9.1 (A), F5.2, J1.19, J8.4
F6-out: D2.2 (K), D3.2 (K), F6.2, J8.3
F7-out: D5.2 (K), D6.1 (A), F7.2, J8.2
GND: D1.2 (K), D14.2 (K), D15.2 (A), D17.2 (K), J1.7, J1.20, J7.1, J9.7, K1.85, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (E), Q6.3 (E), RN1.1 (common)
IAT-Sensor: J1.11, J10.4
unnamed: D1.1 (A), R1.1
unnamed: D6.2 (K), R5.2
unnamed: D7.2 (K), R2.2
unnamed: D8.2 (K), R3.2
unnamed: D9.2 (K), R4.2
unnamed: D12.2 (K), R6.2
unnamed: D13.2 (K), R7.2
unnamed: D14.1 (A), R8.2
unnamed: D16.1 (K), F2.2, K1.87, K2.30, K2.86
unnamed: D17.1 (A), R9.2
unnamed: F1.1, K1.30
unnamed: F3.1, F4.1, F5.1, F6.1, F7.1, K2.87, R9.1
O2-Sensor: J1.25, J10.7
SigRtn: J1.23, J10.3
Spare-ADC: J1.13, J10.8
TPS-Sensor: J1.12, J10.6
Tachometer: J1.2, J9.4, R1.2
VDDA: J1.10, J10.2

Notes on the sheet:
YlGn
Inj1 & Inj2 +
Ign1 & Ign2 +
WB & Tach & PWM Idle +
(Ign1)
(Inj1)
(Ign2)
(Inj2)
(PWM Idle)
Flyback
Battery negative
Battery positive
Battery switched start & run
Tachometer signal
Fuel Pump +
Inj1
Inj2
Ign1
Ign2
IAT
CLT
ADC Gnd
TPS
ADC 5V
WB O2
CKP VR+
CKP VR-
Spare High Current Output +
PWM Idle
Tach & WB & Idle +
Right side vehicle wiring terminals
Left side vehicle wiring terminals
100K
DB25 connections to Buggly SPD board
12 volt from main relay
ASD relay control
Common ground
Sensor ground
Wide Band O2 sensor
Cylinder head temperaure

Board: 2 copper layers, 120.4 x 99.9 mm, 45 parts (0 on the bottom side), 44 nets.

## Commit log

2022-12-08 Create Git Hold
